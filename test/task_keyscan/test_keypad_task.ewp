# IAR project test_keypad_task.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: PART_LM3S8962; ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..; ..\..\..\..\common\include; ..\..\..\..\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: test_keypad_task.bin
  ILINK.IlinkOutputFile: test_keypad_task.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\common\driverlib\ewarm-cm3\Exe\driverlib-cm3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Source
    ../../tasks/: compute.c controller.c display.c enunciate.c key_scan.c measure.c schedule.c serial_comms.c status.c tasks.c
    ../../utils/: float_print.c hardware_timer.c lcd_print.c led_control.c speaker_control.c
    ../../drivers/: pulse_transducer.c rit128x96x4.c
    ../../: startup.c
    ./: test_keypad_task.c
