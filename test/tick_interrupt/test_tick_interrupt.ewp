# IAR project test_tick_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: PART_LM3S8962; ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..; ..\..\..\..\common\include; ..\..\..\..\common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..
  OBJCOPY.OOCOutputFile: test_tick_interrupt.bin
  ILINK.IlinkOutputFile: test_tick_interrupt.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\common\driverlib\ewarm-cm3\Exe\driverlib-cm3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Source
    ../../utils/: hardware_timer.c lcd_print.c
    ../../drivers/: rit128x96x4.c
    ../../: startup.c
    ./: test_tick_interrupt.c
