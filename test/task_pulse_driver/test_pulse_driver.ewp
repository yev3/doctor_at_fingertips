# IAR project test_pulse_driver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..; ..\..\..\..\common\include; ..\..\..\..\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: test_pulse_driver.srec
  ILINK.IlinkOutputFile: measurement_test.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\common\driverlib\ewarm-cm3\Exe\driverlib-cm3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Source
    ../../tasks/: compute.c controller.c display.c enunciate.c key_scan.c measure.c schedule.c serial_comms.c status.c tasks.c
    ../../utils/: float_print.c hardware_timer.c lcd_print.c led_control.c speaker_control.c ustdlib.c
    ../../drivers/: pulse_transducer.c rit128x96x4.c
    ../../: startup.c
    ./: test_pulse_driver.c
