# IAR project test_compute_task.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S8962 TexasInstruments LM3S8962
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..; ..\..\..\..\common\include; ..\..\..\..\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: compute_test.srec
  ILINK.IlinkOutputFile: compute_test.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\common\driverlib\ewarm-cm3\Exe\driverlib-cm3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../tasks/: compute.c controller.c display.c key_scan.c measure.c schedule.c status.c tasks.c warning_alarm.c
    ../../utils/: hardware_timer.c lcd_print.c led_control.c speaker_control.c ustdlib.c
    ../../drivers/: pulse_transducer.c rit128x96x4.c
    ../../: startup.c
    ./: test_compute_task.c
