# IAR project proj5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=; ewarm; PART_LM3S8962
  ICCARM.CCDiagSuppress: pe1644, pe161
  ICCARM.CCIncludePath2: include; ..\common\include; ..\common\FreeRTOS\Source\include; ..\common\FreeRTOS\Source\portable\IAR\ARM_CM3; ..\common\FreeRTOS-Plus\Source\FreeRTOS-Plus-TCP\include; ..\common\FreeRTOS-Plus\Source\FreeRTOS-Plus-TCP\portable\Compiler\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: include
  OBJCOPY.OOCOutputFile: proj5-comms.srec
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3Sxxxx.icf
  ILINK.IlinkAdditionalLibs: ..\common\include\driverlib\ewarm-cm3\Exe\driverlib-cm3.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    include/: FreeRTOSConfig.h FreeRTOSIPConfig.h
    src/: main.c startup_ewarm.c
  group FreeRTOS
    ../common/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    ../common/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../common/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portmacro.h
  group FreeRTOS-TCP
    ../common/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
  group FreeRTOS-TCP/portable
    ../common/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/portable/BufferManagement/: BufferAllocation_2.c
    ../common/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/portable/NetworkInterface/LM3S-8962/: NetworkInterface.c
  group tasks
    src/tasks/: cmd_dispatch.c compute.c computeEKG.c controller.c display.c enunciate.c init.c ipconn.c key_scan.c measure.c measureEKG.c serial_comms.c status.c
  group utils
    src/utils/: float_print.c hardware_timer.c lcd_print.c led_control.c optfft.c pulse_transducer.c RTOSDebugTrace.c RTOSIPTrace.c sockcmdline.c speaker_control.c tables.c
