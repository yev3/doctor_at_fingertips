<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\common\include\driverlib\driverlib-cm3.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\proj5.ewp</path>
    </project>
    <batchBuild />
</workspace>
